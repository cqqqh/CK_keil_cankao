# Keil uVision project Web51.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F340 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: Web52 +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: ANALOG.C ARP.C HTTP.C ICMP.C IP.C MAIN.C TCP.C TIMER.C UDP.C CKSUM.c WEBDOC1.C CP220x_REG.c
